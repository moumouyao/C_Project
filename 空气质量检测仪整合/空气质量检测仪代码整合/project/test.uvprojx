# Keil uVision project test.uvprojx, settings and files
target test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\user\api;..\lib\inc;..\System;..\startup;..\MQTT;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM3;..\Cjson;..\lvgl;..\lvgl\app;..\lvgl\porting;..\lvgl\src;..\lvgl\src\lv_core;..\lvgl\src\lv_draw;..\lvgl\src\lv_font;..\lvgl\src\lv_hal;..\lvgl\src\lv_misc;..\lvgl\src\lv_themes;..\lvgl\src\lv_widgets;..\lvgl\app\my_GUI;..\lvgl\app\my_GUI\guider_customer_fonts;..\lvgl\app\my_GUI\guider_fonts;..\lvgl\app\my_GUI\images
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: stm32f10x_it.c system_stm32f10x.c main.c stm32f10x_conf.h stm32f10x.h FreeRTOSConfig.h
  group startup
    ../startup/: startup_stm32f10x_hd.s
  group api
    ../user/api/: buzzer.c buzzer.h key.c key.h led.c led.h interrupt.c interrupt.h pwm.c pwm.h usart.c usart.h kqm.c kqm.h su_03t.c su_03t.h dht11.c dht11.h ADC.c ADC.h bsp_lcd.c bsp_lcd.h my_spi_flash.c my_spi_flash.h esp8266.c esp8266.h my_mqtt.c my_mqtt.h myrtos.c myrtos.h
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    D:/信盈达环境搭建/MCU/库函数/库函数/lib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group system
    ../System/: Delay.c Delay.h timer.c timer.h MyDMA.c MyDMA.h RTC.c RTC.h
  group photos
    ../user/photos/: 1.c 2.c 4.c 5.c 7.c 8.c 9.c 10.c 11.c 12.c 3.c 6.c
  group mqtt_src
    ../MQTT/: CMakeLists.txt MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group FreeRTOS_core
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_port
    ../FreeRTOS/port/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/port/MemMang/: heap_4.c
  group lvgl_src
    ../lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group lvgl_porting
    ../lvgl/: lv_conf.h
    ../lvgl/porting/: lv_port_disp.c lv_port_disp.h
  group lvgl_app
    ../lvgl/app/: lvgl_app.h lvgl_app.c CH_font24.c
  group my_GUI
    ../lvgl/app/my_GUI/: events_init.c events_init.h setup_scr_screen.c gui_guider.c setup_scr_screen_2.c setup_scr_screen_3.c
    ../lvgl/app/my_GUI/guider_fonts/: lv_font_simsun_12.c lv_font_simsun_18.c lv_font_simsun_20.c lv_font_simsun_24.c
    ../lvgl/app/my_GUI/images/: _1_alpha_50x50.c _2_alpha_50x50.c _3_alpha_50x50.c _4_alpha_50x50.c _5_alpha_50x50.c _6_alpha_50x50.c _7_alpha_20x20.c _didian_alpha_50x50.c _shuaxin_alpha_25x25.c _1x_alpha_50x50.c _4x_alpha_50x50.c _5x_alpha_50x50.c _6x_alpha_50x50.c _8x_alpha_50x50.c _9x_alpha_50x50.c _13x_alpha_50x50.c _17x_alpha_50x50.c _29x_alpha_50x50.c _31x_alpha_50x50.c _0x_alpha_50x50.c screen_3_animimg_3_1w1.c screen_3_animimg_3_1w2.c screen_3_animimg_3_1w3.c screen_3_animimg_3_1w4.c
software components: CMSIS:CORE 5.2.0
