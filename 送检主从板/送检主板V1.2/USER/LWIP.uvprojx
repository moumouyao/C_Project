# Keil uVision project LWIP.uvprojx, settings and files
target LWIP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: F407 +hex
  c flags: uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\ETHERNET;..\HARDWARE\TIMER;..\HARDWARE\LED;..\HARDWARE\SRAM;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\LWIP;..\LWIP\arch;..\LWIP\lwip_header;..\LWIP\app\TCP_Client;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\tcp_server_demo;..\IAP;..\MALLOC;..\HARDWARE\STMFLASH;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\BSP;..\APP;..\FF9;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\DS18B20;..\HARDWARE\power;..\HARDWARE\RTC;..\HARDWARE\LSENS;..\HARDWARE\ADC3;..\HARDWARE\AD;..\HARDWARE\BMP;..\HARDWARE\I2C;..\HARDWARE\KEY;..\LWIP\lwip_app\udp_demo;..\LWIP\lwip_app\web_server_demo;..\LWIP\lwip_app\http;..\LWIP\lwip_app\udp;..\cJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xef800
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c sw_global.c dispose.c IpWhiteList.c Code.c
  group APP
    ../APP/: app.c ctrlcenter_app.c host_app.c dis_app.c Base64.c Base64.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ETHERNET/: LAN8720.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/BSP/: bsp.c sw_controlcenter.c sw_crc16.c wdg.c sdio_sdcard.c sw_host.c user_crc.c user_tim3_pwm.c nvic.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/power/: power.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/LSENS/: lsens.c
    ../HARDWARE/ADC3/: adc3.c
    ../HARDWARE/AD/: AD.c
    ../HARDWARE/BMP/: bmp.c
    ../HARDWARE/I2C/: i2c.c
    ../HARDWARE/KEY/: key.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_fsmc.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_flash.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_crc.c stm32f4xx_iwdg.c stm32f4xx_spi.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group LWIP-APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/tcp_server_demo/: tcp_server_demo.c
    ../LWIP/lwip_app/http/: httpd.c fs.c httpd_cgi_ssi.c
    ../LWIP/lwip_app/udp/: udp_demo.c
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP-ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group MALLOC
    ../MALLOC/: malloc.c
  group UCOSII_PORT
    ../UCOSII/PORT/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group UCOSII_CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group FATFS
    ../FF9/: ff.c diskio.c
  group IAP
    ../IAP/: iap.c
  group cJSON
    ../cJSON/: cJSON.c cJSON.h
  group README
    ../: readme.txt
    ./: NotWarning.txt
  group Doc
    ./: bottom_modify.txt
