# Keil uVision project Infrared_Thermometer.uvproj, settings and files
target Software (MCS-51)
  device: STC8G2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Infrared_Thermometer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\api;.\stc8_lib
  group api
    ./api/: main.c ioConfig.c tim.c uart1.c key.c mlx90614.c power.c
    ./: STARTUP.A51
