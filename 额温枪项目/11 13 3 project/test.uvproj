# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user;.\api
  group Source Group 1
    ./: STARTUP.A51
  group user
    ./user/: main.c main.h
  group api
    ./api/: timer.c timer.h usart.c usart.h LU90614.c LU90614.h lcd_driver.c lcd_driver.h font.c font.h key.c key.h
